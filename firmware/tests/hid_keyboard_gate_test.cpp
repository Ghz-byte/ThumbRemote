#include "../hid_probe/hid_keyboard_gate.h"
#include <cstdio>
int checks=0, failures=0;
#define CHECK(c) do { ++checks; if (!(c)) {++failures; std::printf("FAIL %d: %s\n",__LINE__,#c);} } while(0)
int main() {
  using namespace hid_probe;
  Report r{};
  Gate g;
  CHECK(!g.arm(0)); CHECK(!g.press(touch::Direction::Up,0,0,r));
  g.update(true,1,0);
  CHECK(g.tick(0,r)); CHECK(r==Report{}); CHECK(!g.tick(0,r));
  CHECK(!g.press(touch::Direction::Up,1,0,r));
  CHECK(g.arm(10)); CHECK(g.armed()); CHECK(!g.arm(11));
  CHECK(!g.mode(Mode::Page));
  CHECK(!g.press(touch::Direction::Left,1,10,r));
  CHECK(!g.press(touch::Direction::Right,1,10,r));
  CHECK(!g.press(touch::Direction::Up,0,10,r));
  CHECK(g.press(touch::Direction::Up,1,10,r));
  const Report downArrow={{0,0,0x51,0,0,0,0,0}};
  CHECK(r==downArrow);
  CHECK(!g.press(touch::Direction::Down,1,11,r));
  CHECK(!g.tick(49,r)); CHECK(g.tick(50,r)); CHECK(r==Report{});
  CHECK(!g.tick(51,r)); CHECK(!g.press(touch::Direction::Down,1,549,r));
  CHECK(g.press(touch::Direction::Down,1,550,r)); CHECK(r[2]==0x52);
  g.disarm(551); CHECK(!g.armed()); CHECK(g.tick(551,r)); CHECK(r==Report{});
  CHECK(!g.tick(552,r)); CHECK(g.mode(Mode::Page)); CHECK(g.mode()==Mode::Page);
  CHECK(g.arm(1100)); CHECK(g.press(touch::Direction::Up,1,1100,r)); CHECK(r[2]==0x4e);
  CHECK(g.tick(1140,r));
  CHECK(g.press(touch::Direction::Down,1,1640,r)); CHECK(r[2]==0x4b);
  CHECK(g.tick(1680,r));
  CHECK(!g.press(touch::Direction::Up,1,61100,r)); CHECK(!g.armed());
  g.update(false,2,62000); CHECK(!g.arm(62000));
  g.update(true,3,62001); CHECK(g.tick(62001,r)); CHECK(r==Report{});
  CHECK(!g.armed()); CHECK(!g.press(touch::Direction::Up,1,62001,r));
  CHECK(g.arm(62002)); CHECK(g.press(touch::Direction::Up,3,62002,r));
  g.update(false,4,62003); CHECK(!g.tick(62100,r));
  g.update(true,5,62101); CHECK(g.tick(62101,r)); CHECK(r==Report{});
  CHECK(!g.tick(62102,r)); CHECK(!g.armed());
  Gate wrap;
  wrap.update(true,6,0xfffffff0u); CHECK(wrap.tick(0xfffffff0u,r));
  CHECK(wrap.arm(0xfffffff0u));
  CHECK(wrap.press(touch::Direction::Up,6,0xfffffff0u,r));
  CHECK(!wrap.tick(0x17u,r)); CHECK(wrap.tick(0x18u,r)); CHECK(r==Report{});
  CHECK(!wrap.press(touch::Direction::Up,6,0x20bu,r));
  CHECK(wrap.press(touch::Direction::Up,6,0x20cu,r));
  wrap.disarm(0x20du); CHECK(wrap.tick(0x20du,r)); CHECK(!wrap.armed());
  // A contact that starts before arm is cancelled and requires a release.
  touch::GestureRecognizer recognizer;
  recognizer.observe(touch::QueryState::Idle);
  touch::Report p; p.mask=1; p.points[0].x=200; p.points[0].y=100;
  recognizer.observe(touch::QueryState::Packet,&p);
  recognizer.cancel();
  p.points[0].x=40; recognizer.observe(touch::QueryState::Packet,&p);
  CHECK(recognizer.observe(touch::QueryState::Idle).outcome!=touch::GestureOutcome::Accepted);
  CommandReader reader;
  CHECK(reader.push('a')==Command::None); CHECK(reader.push('r')==Command::None);
  CHECK(reader.push('m')==Command::None); CHECK(reader.push('\n')==Command::Arm);
  CHECK(reader.push('\n')==Command::None);
  for (char c : "armX") if(c) reader.push(c);
  CHECK(reader.push('\n')==Command::Invalid);
  for(int i=0;i<60;i++) reader.push('x');
  for(char c : "arm") if(c) reader.push(c);
  CHECK(reader.push('\n')==Command::Invalid);
  for(char c : "mode page") if(c) reader.push(c);
  CHECK(reader.push('\r')==Command::Page); CHECK(reader.push('\n')==Command::None);
  for(char c : "disarm") if(c) reader.push(c);
  CHECK(reader.push('\n')==Command::Disarm);
  Delivery delivery;
  CHECK(delivery.readable()==Report{});
  CHECK(delivery.offer(downArrow,7,100));
  CHECK(delivery.readable()==Report{});
  CHECK(!delivery.take(false,7,101,r));
  CHECK(delivery.offer(downArrow,7,200));
  CHECK(!delivery.take(true,8,201,r));
  CHECK(delivery.offer(downArrow,9,300));
  delivery.cancel(); CHECK(!delivery.take(true,9,301,r));
  CHECK(delivery.offer(downArrow,9,400));
  CHECK(!delivery.offer(downArrow,9,401));
  CHECK(delivery.offer(Report{},9,402));
  CHECK(delivery.take(true,9,403,r)); CHECK(r==Report{});
  CHECK(delivery.readable()==Report{});
  CHECK(delivery.offer(downArrow,9,500));
  CHECK(delivery.take(true,9,501,r)); CHECK(r==downArrow);
  CHECK(delivery.readable()==Report{}); CHECK(!delivery.take(true,9,502,r));
  CHECK(delivery.offer(downArrow,9,600));
  CHECK(!delivery.take(true,9,701,r));
  CHECK(delivery.offer(Report{},9,800));
  CHECK(delivery.take(true,9,1000,r)); CHECK(r==Report{});
  Gate stoppedRelease; Delivery stoppedDelivery;
  stoppedRelease.update(true,10,0); CHECK(stoppedRelease.tick(0,r));
  CHECK(stoppedRelease.arm(1)); CHECK(stoppedRelease.press(touch::Direction::Up,10,1,r));
  CHECK(stoppedDelivery.offer(r,10,1)); CHECK(stoppedDelivery.take(true,10,2,r));
  CHECK(r==downArrow);
  CHECK(stoppedRelease.tick(41,r)); CHECK(stoppedDelivery.offer(r,10,41));
  stoppedDelivery.cancel(); stoppedRelease.disarm(42);
  CHECK(stoppedRelease.tick(42,r)); CHECK(r==Report{});
  CHECK(stoppedDelivery.offer(r,10,42)); CHECK(stoppedDelivery.take(true,10,43,r)); CHECK(r==Report{});
  std::printf("HID gate: %d checks, %d failures\n",checks,failures);
  return failures?1:0;
}
